# Keil uVision project Uart.uvproj, settings and files
target Uart (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N575F145 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Uart
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DEBUG_ENABLE_SEMIHOST_
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\N575\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_n575_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/N575/Source/ARM/: startup_N575_Keil.s
    ../Library/Device/Nuvoton/N575/Source/: system_N575.c
  group User
    ../: main.c buffer.c parser.c uart_app.c
  group Library
    ../Library/StdDriver/src/: uart.c clk.c retarget.c sys.c pwm.c
