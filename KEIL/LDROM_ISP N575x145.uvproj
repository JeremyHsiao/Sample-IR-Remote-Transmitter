# Keil uVision project LDROM_ISP N575x145.uvproj, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N575F145 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: LDROM_ISP_N575x145
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __N575F145__
  c include: .\;..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\Library\Device\Nuvoton\N575\Include
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --pd="-DSRAM_SIZE=0x3000" --pd="-DROM_SIZE=0x24400" --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group CMSIS
    ../Library/Device/Nuvoton/N575/Source/ARM/: startup_N575_Keil.s
    ../Library/Device/Nuvoton/N575/Source/: system_N575.c
  group User
    ../LDROM_ISP N575x145/: main.c FMCRW.c
  group Library
    ../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c bod.c gpio.c fmc.c
