# Keil uVision project BlueRat.uvproj, settings and files
target BlueRat (ARM-ADS)
  device: N575F145 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: BlueRat
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST_, ENABLE_WATCH_DOG_TIMER
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\N575\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_n575_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/N575/Source/ARM/: startup_N575_Keil.s
    ../Library/Device/Nuvoton/N575/Source/: system_N575.c
  group User
    ../BlueRat/: main.c buffer.c parser.c uart_app.c timer_app.c cmd_proc.c SPI_MCP41_42.c nuvoton_i2c.c SX1509.c
  group Library
    ../Library/StdDriver/src/: uart.c clk.c retarget.c sys.c pwm.c gpio.c timer.c wdt.c acmp.c fmc.c i2c.c
